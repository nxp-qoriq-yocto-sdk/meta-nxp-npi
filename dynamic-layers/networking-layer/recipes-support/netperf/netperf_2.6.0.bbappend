SRC_URI="http://oe-lite.org/mirror/netperf/netperf-${PV}.tar.bz2 \
         file://cpu_set.patch \
         file://vfork.patch \
         file://init"
