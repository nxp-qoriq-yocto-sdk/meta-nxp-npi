# libgcc is required for the target specific libraries to build properly
DEPENDS += "libgcc"
