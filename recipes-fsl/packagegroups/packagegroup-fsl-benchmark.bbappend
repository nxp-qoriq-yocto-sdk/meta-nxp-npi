RDEPENDS_${PN}-core_append = " fio"
RDEPENDS_${PN}-core_append_ls1012a = " iperf3"
