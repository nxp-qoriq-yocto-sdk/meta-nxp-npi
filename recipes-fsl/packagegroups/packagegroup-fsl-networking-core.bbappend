RDEPENDS_${PN}_remove_ls1012a = "inetutils-tftp"
RDEPENDS_${PN}-server_remove_ls1012a = "inetutils-tftpd"
