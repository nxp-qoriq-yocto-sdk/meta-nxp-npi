RDEPENDS_${PN}_append = " \
     expect \
     gmp-dev \
     libmpc-dev \
     mpfr-dev \
"
