RDEPENDS_${PN}_append_ls1043ardb = " ovs-dpdk"
RDEPENDS_${PN}_append_ls1046ardb = " ovs-dpdk"
RDEPENDS_${PN}_append_ls2088ardb = " ovs-dpdk"
