RDEPENDS_${PN}_append_ls1012a = "\
    packagegroup-fsl-multimedia-gstreamer1.0 \
    gstreamer1.0-rtsp-server \
    gstreamer1.0-plugins-bad-meta \
"
