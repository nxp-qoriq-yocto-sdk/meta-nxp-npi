RDEPENDS_${PN}_remove_ls1043a-32b = "lib64-valgrind"
RDEPENDS_${PN}_remove_ls1046a-32b = "lib64-valgrind"
