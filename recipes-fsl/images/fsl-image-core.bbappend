IMAGE_INSTALL_append_ls1012a = " packagegroup-fsl-tools-audio"
