SRCREV = "caec18a71ed702a176892efaf946281b9160e220"

TARGET_ARCH_FMLIB_ls1046a = "arm64a72"
TARGET_ARCH_FMLIB_ls1046a-32b = "arm32a72"
TARGET_ARCH_FMLIB_ls102xa = "arm32a72"
TARGET_ARCH_FMLIB_ls1043a-32b = "arm32a53"
