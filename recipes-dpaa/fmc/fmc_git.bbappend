SRC_URI = "git://sw-stash.freescale.net/scm/dpaamodules/fmc.git;branch=master;protocol=http"
SRCREV = "81e4796fd22e32fe7ab77f075c1879d7bb75c02e"

EXTRA_OEMAKE_PLATFORM_ls1046a = "ls1046"
EXTRA_OEMAKE_PLATFORM_ls102xa = "ls1046"
