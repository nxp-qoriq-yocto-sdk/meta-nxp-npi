SRC_URI = "git://git.freescale.com/ppc/sdk/usdpaa.git;nobranch=1"
SRCREV = "db0ea70dbb599c07144a6d720539e88b8c5291da"
