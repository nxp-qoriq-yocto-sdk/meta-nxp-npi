SRC_URI = "git://source.codeaurora.org/external/qoriq/qoriq-yocto-sdk/usdpaa-apps.git;nobranch=1;protocol=http"
SRCREV = "49fce3aeec2ceb4c7f69f32871f8f0cbc1e04a51"
