SRC_URI = "git://sw-stash.freescale.net/scm/sdk/l2switch-util.git;branch=master;protocol=http"
SRCREV = "2537efa109358883ab50aadca07365ed764de293"
