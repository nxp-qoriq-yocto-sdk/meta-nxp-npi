SRC_URI = "git://git.freescale.com/ppc/sdk/scatter-gather.git;nobranch=1"
SRCREV = "615a52e1e407acb658b9884a20e476d6041e3fbf"

COMPATIBLE_MACHINE = "(ls1021a|ls1046a|ls2088a)"
