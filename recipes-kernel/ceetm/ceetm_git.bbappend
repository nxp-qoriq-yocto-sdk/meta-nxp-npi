COMPATIBLE_MACHINE = "(e6500-64b|t1040|t1042|t1023|t1024|t2080|b4860|b4420|ls1043aqds|ls1043ardb|ls1046a)"
