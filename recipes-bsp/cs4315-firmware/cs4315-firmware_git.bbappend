SRCREV_ls1046a = "a200a938dd28264a0291669b199b9b963e1a24c7"

UCODE_ls1046a = "\
    aquantia/apps/aq_programming.bin \
    aquantia/AQR-G2_v3.1.5-AQR_RevB_AQR107_ID16068_VER385.cld \
"

COMPATIBLE_MACHINE = "(t1023|t1024|t2080|t4240|ls1046a)"
