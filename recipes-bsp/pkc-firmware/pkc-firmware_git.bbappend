SRC_URI = "git://source.codeaurora.org/external/qoriq/qoriq-yocto-sdk/pkc-firmware.git;nobranch=1;protocol=http"
SRCREV = "209e0e6babdab43f38db84591307bedfd0bed542"
