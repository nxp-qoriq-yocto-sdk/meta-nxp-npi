SRC_URI = "git://sw-stash.freescale.net/scm/sdk/u-boot-sdk.git;branch=master;protocol=http"
SRCREV = "7b0fea8ada90cc8a0605bce012c2b0c82d3673d9"
