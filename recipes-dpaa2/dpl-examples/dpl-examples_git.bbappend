SRC_URI = "git://sw-stash.freescale.net/scm/dpaa2/dpl-examples.git;branch=master;protocol=http"
SRCREV = "e02d1267af101d9bdb24db03f5e923a4288dee4d"
COMPATIBLE_MACHINE = "(ls2080a|ls2088a)"
