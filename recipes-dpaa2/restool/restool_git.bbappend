COMPATIBLE_MACHINE = "(ls2080a|ls2088a)"
